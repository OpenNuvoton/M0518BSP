# Keil uVision project FMC_IAP_LD.uvproj, settings and files
target FMC_IAP_LD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M0518SD2AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: FMC_IAP_LD
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --diag_suppress 1296
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M0518\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M0518.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../../../../Library/Device/Nuvoton/M0518/Source/: system_M0518.c
    ../../../../Library/Device/Nuvoton/M0518/Source/ARM/: startup_M0518.s
  group Source files
    ../: main.c LoaderImage.s main_LD.c
  group Library files
    ../../../../Library/StdDriver/src/: retarget.c
