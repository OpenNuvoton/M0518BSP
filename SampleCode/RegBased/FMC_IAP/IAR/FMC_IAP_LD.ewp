# IAR project FMC_IAP_LD.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M0518AE series Nuvoton M0518AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: LDROM=1
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M0518\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FMC_IAP_LD.bin
  ILINK.IlinkOutputFile: FMC_IAP_LD.out
  ILINK.IlinkIcfFile: FMC_IAP_LD.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS Files
    ../../../../Library/Device/Nuvoton/M0518/Source/IAR/: startup_M0518.s
    ../../../../Library/Device/Nuvoton/M0518/Source/: system_M0518.c
  group Library Files
    ../../../../Library/StdDriver/src/: retarget.c
  group Source Files
    ../: main_LD.c
