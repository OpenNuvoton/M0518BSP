# IAR project I2C_Wakeup_Master.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M0518AE series Nuvoton M0518AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\M0518\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: I2C_Wakeup_Master.bin
  ILINK.IlinkOutputFile: I2C_Wakeup_Master.out
  ILINK.IlinkIcfFile: I2C_Wakeup_Master.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS Files
    ../../../../Library/Device/Nuvoton/M0518/Source/IAR/: startup_M0518.s
    ../../../../Library/Device/Nuvoton/M0518/Source/: system_M0518.c
  group Library Files
    ../../../../Library/StdDriver/src/: retarget.c
  group Source Files
    ../: main.c
