# IAR project GPIO_EINTAndDebounce.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M0518AE series Nuvoton M0518AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\M0518\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GPIO_EINTAndDebounce.bin
  ILINK.IlinkOutputFile: GPIO_EINTAndDebounce.out
  ILINK.IlinkIcfFile: GPIO_EINTAndDebounce.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Library/Device/Nuvoton/M0518/Source/IAR/: startup_M0518.s
    ../../../../Library/Device/Nuvoton/M0518/Source/: system_M0518.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c uart.c
  group User
    ../: main.c
